# Repository 74th/74th-oshw-projects

## KiCad design TEST-ch32v003_test_board/ch32v003_test_board.kicad_pcb

Parts:
C1, C3, C4: 10u; Capacitor_0603_1608_WithSizeText
C2: 100n; Capacitor_0603_1608_WithSizeText
CH1, CH2: Pin_10; PinOut_Pin_10
CH5, CH6: Pin_19; PinOut_Pin_20
D1: LED; LED_0805_2012
J1: SWD_10Pin_MCU-Side; Connector_HalfPinHeader_SWD
J2: USB2.0-C_SMT; Connector_USB-C-Receptacle_SMT_12-Pin_Simple
JP1: SWD TXD; SolderJumper-2
JP2: SWD RXD; SolderJumper-2
JP3: SWD SWDIO; PinOut_Pin_2
R1: 22k; Capacitor_0603_1608_WithSizeText
R2: 10k; Capacitor_0603_1608_WithSizeText
SW1: SW_Push; Switch_SKRPABE010
U1: CH32V003F4P6; Package_TSSOP-20_4.4x6.5mm_P0.65mm
U2: AMS1117; Package_SOT-89-3
U3: CH217K; SOT-23-6

Connections:
+3V3: C1.1, C2.1, CH1.9, R2.1, U1.9 (VDD), U2.2 (VO)
+5V: C3.1, U2.3 (VI), U3.1 (VOUT)
/PA1: CH1.5, CH6.6, U1.5 (PA1/ADC1/OSC_IN)
/PA2: CH1.6, CH6.7, U1.6 (PA2/ADC0/OSC_OUT)
/PC0: CH1.10, CH6.10, U1.10 (PC0)
/PC1: CH2.10, CH6.11, U1.11 (PC1/I2C_SDA/SPI_NSS)
/PC2: CH2.9, CH6.12, U1.12 (PC2/I2C_SCL/UART_RTS)
/PC3: CH2.8, CH6.14, U1.13 (PC3)
/PC4: CH2.7, CH6.15, U1.14 (PC4/ADC2)
/PC5: CH2.6, CH6.16, U1.15 (PC5/SPI_SCK)
/PC6: CH2.5, CH6.17, U1.16 (PC6/SPI_MOSI)
/PC7: CH2.4, CH6.19, U1.17 (PC7/SPI_MISO)
/PD0: CH1.8, CH6.9, U1.8 (PD0)
/PD1: CH2.3, CH6.20, JP3.1 (A), U1.18 (SWIO/PD1)
/PD2: CH2.2, CH5.20, U1.19 (PD2/ADC3)
/PD3: CH2.1, CH5.19, U1.20 (PD3/UART_CTS/ADC4)
/PD4: CH1.1, CH6.1, U1.1 (PD4/UART_CK/ADC7)
/PD5: CH1.2, CH6.2, JP1.1 (A), U1.2 (PD5/UART_TX/ADC5)
/PD6: CH1.3, CH6.4, JP2.1 (A), U1.3 (PD6/UART_RX/ADC6)
/PD7: CH1.4, CH6.5, U1.4 (PD7/NRST)
/SWD_RXD: J1.7 (RXD), JP2.2 (B)
/SWD_SWDIO: J1.2 (SWDIO), JP3.2 (B)
/SWD_TXD: J1.8 (TXD), JP1.2 (B)
GND: C1.2, C2.2, C3.2, C4.2, CH1.7, CH5.3, CH5.8, CH5.13, CH5.18, CH6.3, CH6.8, CH6.13, CH6.18, D1.1 (K), J1.3 (GND), J1.5 (GND), J1.9 (GND), R1.2, SW1.1, U1.7 (VSS), U2.1 (GND), U3.2 (GND)
unnamed: D1.2 (A), R2.2
unnamed: SW1.2, U3.4 (EN#)
unnamed: R1.1, U3.5 (ISET)
VBUS: C4.1, CH5.2, J1.1 (VCC), U3.6 (VIN)

Board: 2 copper layers, 50.0 x 54.0 mm, 21 parts (0 on the bottom side), 28 nets.

Other parts of the board:
MISC-ICON: LOGO; Logo_74th_5mm

## KiCad design grove_keymouse/grove_keymouse.kicad_pcb

Board: 2 copper layers, 27.2 x 16.0 mm, 14 parts (7 on the bottom side), 10 nets.

Parts:
C1, C2: 100n; Capacitor_0805_2012
C3: 1u; Capacitor_0805_2012
CH1: UART Port.C; Connector_HY-2.0_SMD_4Pin
D1: Red; LED_0805_2012
D2: LED; LED_0805_2012
J1: USB_TypeA-2.0_Plug; Connector_USB-A-Plug_TH
M1, M2: M2
MISC-ICON: LOGO; Logo_74th_4mm
R1: 10k; Register_0805_2012
R2: 5.1kR; Register_0805_2012
U1: CH9329; SOP-16_3.9x9.9mm_P1.27mm
U2: CH213K; SOT-23

Connections:
/RXD: CH1.2 (Device_RX), U1.8 (RXD)
/TXD: CH1.1 (Device_TX), D2.1 (K), U1.7 (TXD)
/USBDM: J1.2 (D-), U1.13 (UD-)
/USBDP: J1.3 (D+), U1.12 (UD+)
GND: C1.2, C2.2, C3.2, CH1.4 (GND), D1.1 (K), J1.4 (GND), U1.14 (GND), U2.1 (GND)
unnamed: D2.2 (A), R1.2
unnamed: D1.2 (A), R2.2
unnamed: J1.1 (VBUS), U2.3 (VI+)
unnamed: C1.1, U1.16 (V33)
VBUS: C2.1, C3.1, R1.1, R2.1, U1.15 (VCC), U2.2 (VO-)

## KiCad design grove_qwiic_breadboard/grove_qwiic_breadboard.kicad_pcb

File grove_qwiic_breadboard/README.md:

# ブレッドボードで Grove、Qwiic を扱う為のアダプタ

I2C プルアップ付き

Parts:
C1, C2: 0.1u; Capacitor_0603_1608
C3: 10u; Capacitor_0603_1608
CH1, CH5: Breadboard Power; PinOut_Pin_2
CH2: Breadboard GND; PinOut_Pin_2
CH3: Breadboard I2C; PinOut_Pin_2
CH4: Grove; Connector_HY-2.0_SMD_4Pin
CH6: Qwiic; Connector_SH-1.0_SMD_4Pin
JP1: Jumper_2_Open; PinOut_Pin_2
JP2: PinOut_PokaYoke
R1, R2: 1k; Register_0603_1608
U1: AP7333-33SAG; Package_SOT-23

Connections:
+3V3: C1.1, JP1.2 (B), R1.1, R2.1, U1.2 (VO)
/SCL: CH4.1 (SCL), CH6.1 (SCL), JP2.4 (A2), R2.2
/SDA: CH4.2 (SDA), CH6.2 (SDA), JP2.1 (A1), R1.2
GND: C1.2, C2.2, C3.2, CH2.1, CH2.2, CH4.4 (GND), CH6.4 (GND), U1.3 (GND)
unnamed: CH3.2, JP2.3 (A2)
unnamed: CH3.1, JP2.2 (B1)
VCC: C2.1, C3.1, CH1.1, CH1.2, CH4.3 (VCC), CH5.1, CH5.2, CH6.3 (VCC), JP1.1 (A), U1.1 (VI)

Board: 2 copper layers, 33.0 x 14.0 mm, 15 parts (7 on the bottom side), 7 nets.

Other parts of the board:
MISC-ICON: LOGO; Logo_74th_4mm

## KiCad design grove_qwiic_debug_adapter/grove_qwiic_debug_adapter.kicad_pcb

File grove_qwiic_debug_adapter/README.md:

# Grove と qwiic の信号を読み取るアダプタ

- semantics: [pdf](grove_qwiic_debug_adapter/grove_qwiic_debug_adapter-semantics-v1.0.0.pdf) [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2F74th-open-source-hardware-projects%2Fblob%2Fgrove_qwiic_debug_adapter%2Fv1.0.0%2Fgrove_qwiic_debug_adapter%2Fgrove_qwiic_debug_adapter.kicad_sch)
- pcb: [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2F74th-open-source-hardware-projects%2Fblob%2Fgrove_qwiic_debug_adapter%2Fv1.0.0%2Fgrove_qwiic_debug_adapter%2Fgrove_qwiic_debug_adapter.kicad_pcb)

Parts:
C1, C2: 100n; Capacitor_0603_1608
CH1, CH2: Grove; Connector_HY-2.0_SMD_4Pin
CH3: Pin_4; PinOut_Pin_4
CH4, CH5: Qwiic; Connector_SH-1.0_SMD_4Pin
R1, R2: 1k; Register_0603_1608
U1: AP7333-33SAG; Package_SOT-23

Connections:
/D0: CH1.1 (SCL), CH2.1 (SCL), CH3.1, CH4.1 (SCL), CH5.1 (SCL), R2.2
/D1: CH1.2 (SDA), CH2.2 (SDA), CH3.2, CH4.2 (SDA), CH5.2 (SDA), R1.2
GND: C1.2, C2.2, CH1.4 (GND), CH2.4 (GND), CH3.4, CH4.4 (GND), CH5.4 (GND), U1.3 (GND)
unnamed: C2.1, R1.1, R2.1, U1.2 (VO)
VCC: C1.1, CH1.3 (VCC), CH2.3 (VCC), CH3.3, CH4.3 (VCC), CH5.3 (VCC), U1.1 (VI)

Board: 2 copper layers, 35.6 x 25.4 mm, 11 parts (1 on the bottom side), 5 nets.

Other parts of the board:
MISC-ICON: LOGO; Logo_74th_5mm

## KiCad design grove_universal_board/grove_universal_board.kicad_pcb

File grove_universal_board/README.md:

# Grove デバイスを作るためのユニバーサル基板

Shop: https://74th.booth.pm/items/5935664

- semantics: [pdf](./grove_universal_board-semantics-v1.1.0.pdf) [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2F74th-open-source-hardware-projects%2Fblob%2Fgrove_universal_board%2Fv1.1.0%2Fgrove_universal_board%2Fgrove_universal_board.kicad_sch)
- pcb: [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2F74th-open-source-hardware-projects%2Fblob%2Fgrove_universal_board%2Fv1.1.0%2Fgrove_universal_board%2Fgrove_universal_board.kicad_pcb)

## feature

- Grove コネクタを搭載
- 2、3 つのスルーホールが接続された状態になっており、ワイヤーを挿入してはんだ実装することができる（通常のユニバーサル基板はワイヤー実装面でスルーホールに挿入せず、スルーホール上のランドに接続して実装する）
- 電源 5V 供給時に、3.3V を使用できるレギュレータを追加可能にする
- ジャンパ JP1 を接続すると、ユニバーサル基板上の VCC に Grove の VCC を直結させることができる
- I2C 用のプルアップ抵抗を接続可能

## 作例

## 使い方

### ユニバーサル基板としての使い方

シルクでラインで繋がれたスルーホール同士は接続しています。
ワイヤーを差し込んで配線することが可能です。
一般的なユニバーサル基板とは異なることを留意してください。

### 電源の接続方法（v1.1.0）

U1、JP1 を実装するかどうかで、

| Grove で供給される VCC | 基板上の VCC | U1      | JP1                |
| ---------------------- | ------------ | ------- | ------------------ |
| 5V                     | 5V           | 未実装  | 接続（クローズ）   |
| 5V                     | 3.3V         | 実装    | 未接続（オープン） |
| 3.3V                   | 3.3V         | 未実装※ | 接続（クローズ） ※ |

※ 若干電圧降下はあるが、U1 を実装し、JP1 をオープンでも良い。

### I2C の場合のプルアップ方法（v1.1.0）

Grove ホスト側に I2C 用のプルアップ抵抗がない場合、R1、R2 を実装することで、プルアップを行うことができます。

## v1.1.0

- 5V から 3.3V へのレギュレータを追加可能に
- I2C プルアップ抵抗を追加可能に
- VCC と GND をデバイス接続ピンの近くに配置
- Grove の各ポートにアクセスできるスルーホールを追加（ロジックアナライザ等に最適）

### BOM

| Reference | Name                                  | Quantity |
| --------- | ------------------------------------- | -------- |
| C1,C2     | Capacitor 0603 10uF(NC)               | 2        |
| CH18      | HY2.0 Socket SMD 4Pin (Grove) - Grove | 1        |
| R1,R2     | Register 0603 1kΩ(NC)                 | 2        |
| U1        | Regulator 3.3V SOT-89 AMS1117-3.3(NC) | 1        |

- C1、C2、U1 は 5V 電源供給し、3.3V を使用する場合のみ実装します
- R1、R2 は I2C 用のプルアップを追加する場合のみに実装します

## v1.0.0

Grove ポートと、3 連スルーホールだけのシンプルなバージョン。

- pcb: [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2F74th-open-source-hardware-projects%2Fblob%2Fgrove_universal_board%2Fv1.0.0%2Fgrove_universal_board%2Fgrove_universal_board.kicad_pcb)

Board: 2 copper layers, 33.0 x 22.9 mm, 32 parts (9 on the bottom side), 16 nets.

Parts:
C1, C2: 10u; Capacitor_0603_1608
CH1, CH2, CH3, CH4, CH5, CH6, CH7, CH8, CH9, CH13, CH14, CH15, CH16: Pin_1; PinOut_Pin_3
CH10, CH11: Pin_1; PinOut_Pin_2
CH12: Pin_1; PinOut_Pin_4_GND
CH17, CH19: Pin_1; PinOut_Pin_3_Square
CH18: Grove; Connector_HY-2.0_SMD_4Pin
CH20: Pin_1; PinOut_Universal-Board_bridge6_with-Jumper
CH21: Pin_1; PinOut_Universal-Board_bridge6_with-Jumper_Square
JP1: Jumper_2_Open; SolderJumper-2
M1, M2, M3, M4: Hole_M2_2.0
MISC-ICON: LOGO; Logo_74th_5mm
R1, R2: 1k; Register_0603_1608
U1: AMS1117; SOT-89-3

Connections:
+5V: C2.1, CH12.3, CH18.3 (VCC), JP1.1 (A), U1.3 (VI)
/D0/SCL: CH10.1, CH10.2, CH12.1, CH18.1 (SCL), R2.2
/D1/SDA: CH11.1, CH11.2, CH12.2, CH18.2 (SDA), R1.2
GND: C1.2, C2.2, CH12.4, CH17.1, CH17.2, CH17.3, CH18.4 (GND), CH19.1, CH19.2, CH19.3, CH21.1, CH21.2, CH21.3, CH21.4, CH21.5, CH21.6, U1.1 (GND)
unnamed: CH16.1, CH16.2, CH16.3
unnamed: CH14.1, CH14.2, CH14.3
unnamed: CH13.1, CH13.2, CH13.3
unnamed: CH9.1, CH9.2, CH9.3
unnamed: CH7.1, CH7.2, CH7.3
unnamed: CH5.1, CH5.2, CH5.3
unnamed: CH4.1, CH4.2, CH4.3
unnamed: CH3.1, CH3.2, CH3.3
unnamed: CH2.1, CH2.2, CH2.3
unnamed: CH1.1, CH1.2, CH1.3
unnamed: CH8.1, CH8.2, CH8.3
VCC: C1.1, CH20.1, CH20.2, CH20.3, CH20.4, CH20.5, CH20.6, JP1.2 (B), R1.1, R2.1, U1.2 (VO)

## KiCad design test-lipo_battery/test-lipo_battery.kicad_pcb

Parts:
C1, C3: 22u; Capacitor_0805_2012
C2: 22n; Capacitor_0805_2012
C4, C6: 4.7u; Capacitor_0805_2012
C5: 22p; Capacitor_0805_2012
D1, D3, D5: PMEG2010ER,115; Package_SOD123W
D2: Blue; LED_0805_2012
D4: Yellow; LED_0805_2012
J1: USB2.0-C_SMT; Connector_USB-C-Receptacle_SMT_12-Pin_Simple
J2: VUSB PH-2P; Connector_PH-2.0_TH-Vertical_2Pin
J3: VUSB TH-2P; PinOut_Pin_2_GND
J4: 3V3 PH-2P; Connector_PH-2.0_TH-Vertical_2Pin
J5: 3V3 TH-2P; PinOut_Pin_2_GND
J6: VDD PH-2P; Connector_PH-2.0_TH-Vertical_2Pin
J7: VDD TH-2P; PinOut_Pin_2_GND
J8, J9: VBAT PH-2P; Connector_PH-2.0_TH-Vertical_2Pin
J10: VBAT TH-2P; PinOut_Pin_2_GND
JP1: VUSB Conn; SolderJumper-2
L1: 4.7u; Capacitor_0805_2012
Q1, Q2, Q3: IRLML6402; Package_SOT-23
R1, R2: 5.1k; Register_0805_2012
R3: 1k; Register_0805_2012
R4: 33k; Register_0805_2012
R5, R7, R8: 10k; Register_0805_2012
R6: 2k; Register_0805_2012
SW1: VBAT SW; Switch_Slide_SK-12D02-G020
U1: MT2492; Package_SOT-23-6
U2: MCP73831-2-OT; Package_SOT-23-5

Connections:
+3V3: C1.1, C5.1, J4.1 (+), J5.1 (+), L1.2, R4.1
GND: C1.2, C3.2, C4.2, C6.2, D2.1 (K), J1.4 (GND), J2.2 (-), J3.2 (-), J4.2 (-), J5.2 (-), J6.2 (-), J7.2 (-), J8.2 (-), J9.2 (-), J10.2 (-), Q1.1 (G), Q2.1 (G), Q3.1 (G), R1.2, R2.2, R5.2, R6.2, U1.2 (GND), U2.2 (V_{SS})
unnamed: D1.2 (A), J1.1 (VBUS), Q1.3 (D)
unnamed: D4.2 (A), R3.2
unnamed: D4.1 (K), U2.1 (STAT)
unnamed: D3.1 (K), JP1.1 (A), Q2.2 (S)
unnamed: D5.1 (K), Q3.2 (S), SW1.1 (A)
unnamed: D2.2 (A), R8.2
unnamed: J1.5 (CC1), R2.1
unnamed: J1.6 (CC2), R1.1
unnamed: R6.1, U2.5 (PROG)
unnamed: C2.1, U1.1 (BS)
unnamed: R7.2, U1.4 (EN)
unnamed: C5.2, R4.2, R5.1, U1.3 (FB)
unnamed: C2.2, L1.1, U1.6 (SW)
VBAT: C6.1, D5.2 (A), J8.1 (+), J9.1 (+), J10.1 (+), Q3.3 (D), U2.3 (V_{BAT})
VDD: C3.1, J6.1 (+), J7.1 (+), JP1.2 (B), R7.1, R8.1, SW1.2 (B), U1.5 (VIN)
VUSB: C4.1, D1.1 (K), D3.2 (A), J2.1 (+), J3.1 (+), Q1.2 (S), Q2.3 (D), R3.1, U2.4 (V_{DD})

Notes on the sheet:
ミニDCDC
MCP73831 リチウムイオン電池充電回路
MOSFETをDiodeの代わりとして使う場合の 接続が誤っていてたので MOSFETに意味はなし
USB Power
DCDCの電源選択

Board: 2 copper layers, 34.3 x 39.4 mm, 38 parts (0 on the bottom side), 18 nets.

Other parts of the board:
MISC-ICON: LOGO; 74th-4mm

## KiCad design usb_adapter_a-male_to_c-female/usb_adapter_a-male_to_c-female.kicad_pcb

Parts:
J1: USB_TypeA-2.0_Plug; Connector_USB-A-Plug_TH
J2: USB2.0-C_SMT; Connector_USB-C-Receptacle_SMT_12-Pin_Simple
R1, R2: 56k; Register_0805_2012

Connections:
GND: J1.4 (GND), J2.4 (GND)
unnamed: J1.3 (D+), J2.3 (D+)
unnamed: J1.2 (D-), J2.2 (D-)
unnamed: J1.1 (VBUS), J2.1 (VBUS), R1.1, R2.1
unnamed: J2.5 (CC1), R2.2
unnamed: J2.6 (CC2), R1.2

Board: 2 copper layers, 16.5 x 14.5 mm, 5 parts (2 on the bottom side), 6 nets.

Other parts of the board:
M2: Hole_M1.6_1.6
