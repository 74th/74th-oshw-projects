# Repository 74th/74th-oshw-projects

File README.md:

# @74th's public PCB projects

@74th の公開している PCB のプロジェクト

> [!Caution]
> 2024/08/08 Directory structure changed (added IDs for 74TH-G050, etc.). Some of the links printed in the instruction manuals of the PCBs we used to distribute may be broken. Please read and use them as appropriate.
> ※ 2024/08/08 ディレクトリ構成を変更しました（74TH-G050 等の ID を追加しました）。一部、かつてに頒布した基板の取説で印刷したリンクが切れている場合があります。 適宜、読み替えて利用をお願いします。

## Projects included in this repository

このリポジトリに含まれているプロジェクト

### Main project

- 2024-12 [[74TH-G060]7Seg Grove](./74TH-G060-7seg-grove/): four 7-segment LEDs using the I2C protocol via Grove: Grove I2Cで7セグLEDを制御できるモジュール。
- 2024-08 [[74TH-G054]Grove Keymouse](./74TH-G054-grove_keymouse/): Grove UART device that uses CH9329 to act as keyboard and mouse via UART. CH9329 を使って UART 経由でキーボード、マウスとして振るわせる、Grove UART デバイス
- 2024-07 [[74TH-G053]USB Switch Adapter](./74TH-G053-usb_switch_adapter/): スイッチを追加する USB アダプタ
- 2024-06 [[74TH-G050]Grove Universal Board](./74TH-G050-grove_universal_board/): Grove デバイスを作るための小型ユニバーサル基板
- 2024-06 [[74TH-G049]Grove Qwiic debug adapter](./74TH-G049-grove_qwiic_debug_adapter/): Grove と qwiic の信号を読み取るアダプタ
- 2024-05 [[74TH-G048]Grove Qwiic breadboard bridge](./74TH-G048-grove_qwiic_breadboard_bridge/): ブレッドボードで Grove、Qwiic を扱う為のアダプタ。I2C プルアップ付き。

### Sub project

- 2024-07 [MISC-usb_adapter_a-male_to_c-female](./MISC-usb_adapter_a-male_to_c-female/): USB Type-A オス → USB Type-C メス アダプタ

### Testing

- 2024-05 [TEST-test-lipo_battery](./TEST-test-lipo_battery/): リポバッテリー充電 IC と、DCDC コンバータの、74th の学習用基盤

##  Other @74th OSH projects (with publicly available KiCad files)

その他の @74th の OSH プロジェクト（KiCad ファイルを公開しているもの）

- [74th/ch32v-dev-boards](https://github.com/74th/ch32v-dev-boards): Development boards using WCH's RISC-V MCU, CH32V series. WCH の RISC-V MCU、CH32V シリーズを使った開発ボード
- [74th/esp32-dev-boards](https://github.com/74th/esp32-dev-boards): Development boards using Espressif's ESP32 series. Espressif の ESP32 シリーズを使った開発ボード
- [74th/stm32-promicro](https://github.com/74th/stm32-promicro): ProMicro type development board using STMicro's STM32 series. STMicro の STM32 シリーズを使った ProMicro 型開発ボード
- [74th/esp32c3-iot-client-board](https://github.com/74th/esp32c3-iot-client-board): IoT client board using Espressif's ESP32-C3. Espressif の ESP32-C3 を使った IoT クライアントボード
- [74th/tv-side-keyboard-SparrowTV](https://github.com/74th/tv-side-keyboard-SparrowTV):  TV side keyboard. TV 横キーボード
- [74th/relay-switch-usbhub](https://github.com/74th/relay-switch-usbhub): USB hub that switches using relays. リレーを使ってスイッチする USB ハブ
- [74th/ch32v203-daplink-pcb](https://github.com/74th/ch32v203-daplink-pcb): CH32V203 を使った DAPLink
- [74th/usb-c-dip-kit](https://github.com/74th/usb-c-dip-kit):  DIP a Type-C socket. Type-C ソケットを DIP 化

## Using KiCad ライブラリ

- [74th/kicad-parts](https://github.com/74th/74th-kicad-parts): KiCad library used by 74th. 74th が利用している KiCad ライブラリ

## License

MIT License

## KiCad design 74TH-G060-7seg-grove/74TH-G060-7seg-grove.kicad_pcb

File 74TH-G060-7seg-grove/README.md:

# 7Seg Grove

This module allows you to control four 7-segment LEDs using I2C signals through a Grove connector.

🇯🇵 7セグLEDをI2Cで制御するGroveモジュール

Movie tweet: https://x.com/74th/status/1870251968486355227

## I2C Protocol

- Address: 0x73

example: [Sample Firmware (](./sample-firmware/)

### Registers

| address |                                               | R/W | reset |
| ------- | --------------------------------------------- | --- | ----- |
| 0x00    | Direct IO for LED 1                           | R/W | 0x00  |
| 0x01    | Direct IO for LED 2                           | R/W | 0x00  |
| 0x02    | Direct IO for LED 3                           | R/W | 0x00  |
| 0x03    | Direct IO for LED 4                           | R/W | 0x00  |
| 0x10    | Number uint16 input(Upper bit)                | W   | 0x00  |
| 0x11    | Number uint16 input(lower bit)                | W   | 0x00  |
| 0x12    | Point location(0x00 is OFF) (Not Impremented) | W   | 0x00  |

#### Direct IO bits

| bit | Function              |
| --- | --------------------- |
| 1   | LED A(1: ON, 0: OFF)  |
| 2   | LED B(1: ON, 0: OFF)  |
| 3   | LED C(1: ON, 0: OFF)  |
| 4   | LED D(1: ON, 0: OFF)  |
| 5   | LED E(1: ON, 0: OFF)  |
| 6   | LED F(1: ON, 0: OFF)  |
| 7   | LED G(1: ON, 0: OFF)  |
| 8   | LED DP(1: ON, 0: OFF) |

## PCB Documents

### 1.0.0-1.0.1

- 1.0.1（未発売）: Groveソケットの位置を微調整。回路図上のピンの名前を修正。
  - semantics [PDF](semantics-1.0.1.pdf) [KiCanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2F74th-oshw-projects%2Fblob%2F7seg-grove%2F1.0.1%2F74TH-G060-7seg-grove%2F74TH-G060-7seg-grove.kicad_sch)
  - PCB [KiCanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2F74th-oshw-projects%2Fblob%2F7seg-grove%2F1.0.1%2F74TH-G060-7seg-grove%2F74TH-G060-7seg-grove.kicad_pcb)
- 1.0.0
  - semantics [PDF](semantics-1.0.0.pdf) [KiCanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2F74th-oshw-projects%2Fblob%2F7seg-grove%2F1.0.0%2F74TH-G060-7seg-grove%2F74TH-G060-7seg-grove.kicad_sch)
  - PCB [KiCanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2F74th-oshw-projects%2Fblob%2F7seg-grove%2F1.0.0%2F74TH-G060-7seg-grove%2F74TH-G060-7seg-grove.kicad_pcb)

#### BOM

- 利用したいGroveポートの電源電圧にあわせて、実装してください
  - VCCに3.3Vを流す場合: U7を未実装にし、JP1を短絡してください
  - VCCに5Vを流す場合（M5Stackなど）: U7を実装にし、JP1を未接続にしてください
- CH2 Groveソケットは、U1-4 7セグLEDより先に実装してください。7セグLEDは高さがあるため、はんだ付けが若干難しくなります。

| Reference | Name                                                 | Package         | Quantity |
| --------- | ---------------------------------------------------- | --------------- | -------- |
| C1        | Capacitor 100nF                                      | SMD I0603 M1608 | 1        |
| C2-3      | Capacitor 10uF                                       | SMD I0603 M1608 | 2        |
| CH2       | HY2.0 (Grove) or SH1.0 (Qwiic) Socket SMD 4Pin - I2C | SMD             | 1        |
| D1        | LED BLUE                                             | SMD I0805 M2012 | 1        |
| R1-8      | Register 100Ω                                        | SMD I0603 M1608 | 8        |
| R9        | Register 10kΩ                                        | SMD I0603 M1608 | 1        |
| R10-11    | Register 1kΩ                                         | SMD I0603 M1608 | 2        |
| U1-4      | 7Seg LED OSL10561-LW                                 | TH              | 4        |
| U5        | MCU WCH CH32V003F4P6                                 | TSSOP20         | 1        |
| U6        | USB Power Protection IC CH213K                       | SOT-23          | 1        |
| U7        | Regulator 3.3V AMS1117-3.3                           | SOT-89          | 1        |

## Firmware for CH32V003

using ch32v003fun.

[./firmware/](./firmware/)

🇯🇵 キットに付属のCH32V003には、既に書き込んであります

## Sample Firmware for M5Stack Atom Lite

There is a sample firmware that allows you to see this module in action. It uses M5Stack Atom Lite.

Please check [./sample-firmware/](./sample-firmware/) for how to write it.

🇯🇵 このモジュールの動きを確認できるサンプルのファームウェアがあります。 M5Stack Atom Liteを使います。

書き込み方法などは[./sample-firmware/](./sample-firmware/)を確認ください。

[./sample-firmware/](./sample-firmware/)

## only use ch32v003 firmware

Since the firmware has the following pinout, you can also just use the CH32V003F4P6 and this firmware without using this module. See the schematic for details.

🇯🇵 以下のピン配置のファームウェアとなっているため、本モジュールを使わずに、CH32V003F4P6と本ファームウェアを使うだけを使うこともできます。詳しくは回路図を見てください。

| Pin No | Pin   | Role                |
| ------ | ----- | ------------------- |
| 1      | PD4   | LED3 Cassode Common |
| 2      | PD5   | LED2 Cassode Common |
| 3      | PD6   | LED1 Cassode Common |
| 4      | NRST  | - (Internal PullUp) |
| 5      | PA1   | All LEDs SDP        |
| 6      | PA2   | I2C Indicator LED   |
| 7      | GND   | GND                 |
| 8      | PD0   | -                   |
| 9      | VDD   | 3.3V                |
| 10     | PC0   | LED4 Cassode Common |
| 11     | PC1   | I2C SDA             |
| 12     | PC2   | I2C SCL             |
| 13     | PC3   | All LEDs SB         |
| 14     | PC4   | All LEDs SA         |
| 15     | PC5   | All LEDs SF         |
| 16     | PC6   | All LEDs SG         |
| 17     | PC7   | All LEDs SE         |
| 18     | SWDIO | SWDIO               |
| 19     | PD2   | All LEDs SD         |
| 20     | PD3   | All LEDs SC         |

Parts:
C1: 100n; Capacitor_0603_1608
C2, C3: 10u; Capacitor_0603_1608
CH1: SWD; PinOut_Pin_3_3GND
CH2: I2C; Connector_Grove_or_Qwiic
CH3: I2C; Pad_4
D1: LED; LED_0805_2012
JP1: INPUT 3V3; SolderJumper-2
R1, R2, R3, R4, R5, R6, R7, R8: 100; Register_0603_1608
R9: 10k; Register_0603_1608
R10, R11: 1k; Register_0603_1608
U1, U2, U3, U4: OSL10561-LW; Display7Seg_OSL10561-LW
U5: CH32V003F4P6; Package_TSSOP-20_4.4x6.5mm_P0.65mm
U6: CH213K; Package_SOT-23
U7: AMS1117; Package_SOT-89-3

Connections:
+3V3: C1.1, CH1.1 (VCC), R9.2, R10.2, R11.2, U5.9 (VDD), U6.2 (VO-)
/SA: R1.1, U1.7 (A), U2.7 (A), U3.7 (A), U4.7 (A)
/SB: R5.2, U1.6 (B), U2.6 (B), U3.6 (B), U4.6 (B)
/SC: R8.2, U1.4 (C), U2.4 (C), U3.4 (C), U4.4 (C)
/SCL: CH2.1 (SCL), CH3.1 (SCL), R10.1, U5.12 (PC2/I2C_SCL/UART_RTS)
/SD: R3.2, U1.2 (D), U2.2 (D), U3.2 (D), U4.2 (D)
/SDA: CH2.2 (SDA), CH3.2 (SDA), R11.1, U5.11 (PC1/I2C_SDA/SPI_NSS)
/SDP: R4.1, U1.5 (DP), U2.5 (DP), U3.5 (DP), U4.5 (DP)
/SE: R7.1, U1.1 (E), U2.1 (E), U3.1 (E), U4.1 (E)
/SEL1: U4.3 (CC), U4.8 (CC), U5.16 (PC6/SPI_MOSI)
/SEL2: U3.3 (CC), U3.8 (CC), U5.15 (PC5/SPI_SCK)
/SEL3: U2.3 (CC), U2.8 (CC), U5.17 (PC7/SPI_MISO)
/SEL4: U1.3 (CC), U1.8 (CC), U5.5 (PA1/ADC1/OSC_IN)
/SF: R6.1, U1.9 (F), U2.9 (F), U3.9 (F), U4.9 (F)
/SG: R2.1, U1.10 (G), U2.10 (G), U3.10 (G), U4.10 (G)
/SWDIO: CH1.2 (SWDIO), R3.1, U5.18 (SWIO/PD1)
GND: C1.2, C2.2, C3.2, CH1.3 (GND), CH2.4 (GND), CH3.4 (GND), U5.7 (VSS), U6.1 (GND), U7.1 (GND)
unnamed: D1.2 (A), R9.1
unnamed: D1.1 (K), U5.6 (PA2/ADC0/OSC_OUT)
unnamed: C2.1, JP1.2 (B), U6.3 (VI+), U7.2 (VO)
unnamed: R5.1, U5.8 (PD0)
unnamed: R8.1, U5.19 (PD2/ADC3)
unnamed: R4.2, U5.20 (PD3/UART_CTS/ADC4)
unnamed: R7.2, U5.1 (PD4/UART_CK/ADC7)
unnamed: R2.2, U5.2 (PD5/UART_TX/ADC5)
unnamed: R6.2, U5.3 (PD6/UART_RX/ADC6)
unnamed: R1.2, U5.4 (PD7/NRST)
VBUS: C3.1, CH2.3 (VCC), CH3.3 (VCC), JP1.1 (A), U7.3 (VI)

Notes on the sheet:
MCU
MCU Debug Port
Power Select
Host Port
7Seg LEDs
メモ - GPIOだけで4つドライブできるか？ MOSFETを経由する必要があるか？ -> 大丈夫そう！ - 前に抵抗はいるかどうか。3.3Vだしなくても良い？ -> 直接でもよさそうだが、一応抵抗入れておこう - 各モジュール毎に電流制限抵抗が必要か？ 4つまとめて1個で良いか。 -> それぞれ別のタイミングで流すので1個でよさそう

Board: 2 copper layers, 70.0 x 20.5 mm, 31 parts (21 on the bottom side), 28 nets.

Other parts of the board:
M1, M2, M3, M4: Hole_M2_2.2-TH
MISC-ICON: LOGO; Logo_74th_7.5mm

## KiCad design 74TH-G071-grove_uart_usb_adapter/74TH-G071-grove_uart_usb_adapter.kicad_pcb

Parts:
C2, C3, C6: 0.1u; Capacitor_0603_1608
C4: 10u; Capacitor_0603_1608
CH1: UART; Connector_HY-2.0_SMD_4Pin
F1: KT6-1100SMDI; Package_Fuse_1812_4532m
J1: USB2.0-C_SMT; Connector_USB-C-Receptacle_SMT_12-Pin_Simple
JP1: Jumper_2_Open; SolderJumper-2
R1, R2: 5.1k; Register_0603_1608
R3, R4, R5, R6: 0; Register_0603_1608
U1: CH340C; Package_SOIC-16_3.9x9.9mm_P1.27mm
U2: CH213K; Package_SOT-23

Connections:
+5V: F1.2, JP1.2 (B)
/D+: J1.3 (D+), U1.5 (UD+)
/D-: J1.2 (D-), U1.6 (UD-)
/RXD: R4.2, R6.2, U1.3 (RXD)
/TXD: R3.2, R5.2, U1.2 (TXD)
GND: C2.2, C3.2, C4.2, C6.2, CH1.4 (GND), J1.4 (GND), J1.S1 (SHIELD), R1.2, R2.2, U1.1 (GND), U2.1 (GND)
unnamed: CH1.1 (Host_RX), R3.1, R4.1
unnamed: CH1.2 (Host_TX), R5.1, R6.1
unnamed: C4.1, CH1.3 (VCC), JP1.1 (A)
unnamed: J1.5 (CC1), R1.1
unnamed: J1.6 (CC2), R2.1
unnamed: C2.1, U1.4 (V3)
unnamed: C3.1, U1.16 (VCC), U2.2 (VO-)
VBUS: C6.1, F1.1, J1.1 (VBUS), U2.3 (VI+)

Board: 2 copper layers, 14.7 x 32.0 mm, 18 parts (15 on the bottom side), 14 nets.

Other parts of the board:
MISC-ACCOUNTTEXT: Logo_74th_text
MISC-ICON: LOGO; Logo_74th_5mm

## KiCad design 74TH-G073-m5atom_breakout/74TH-G073-m5atom_breakout.kicad_pcb

Parts:
CH1: Pin_4; PinOut_Pin_4_GND_OneSide
CH2: Pin_5; PinOut_Pin_5_OneSide
U1: M5Stack AtomS3; Breakout_M5Stack_Atom_Socket_no-outline

Connections:
unnamed: CH2.5, U1.9 (3V3)
unnamed: CH1.3, U1.3 (5V)
unnamed: CH2.4, U1.8 (G5/A4)
unnamed: CH2.3, U1.7 (G6/A5)
unnamed: CH2.2, U1.6 (G7/A6)
unnamed: CH2.1, U1.5 (G8/A7)
unnamed: CH1.2, U1.2 (G38)
unnamed: CH1.1, U1.1 (G39)
unnamed: CH1.4, U1.4 (GND)

Board: 2 copper layers, 24.0 x 37.4 mm, 4 parts (1 on the bottom side), 9 nets.

Other parts of the board:
MISC-ICON: LOGO; Logo_74th_7.5mm

## KiCad design 74TH-G070-USB_Power_Adapter/74TH-G070-USB_Power_Adapter.kicad_pcb

Parts:
C1, C2: 22u; Capacitor_0805_2012
C3: 100n; Register_0603_1608
D1, D2, D3: D; D_SOD-128
J1: Power_USB; Connector_USB-C-Receptacle_SMT_12-Pin_Simple
J2: CONN_USB; Connector_USB-C-Receptacle_SMT_12-Pin_Simple
J3: Downstream_USB; Connector_USB-C-Receptacle_SMT_12-Pin_Simple
JP1, JP2, JP3: Jumper_2_Open; SolderJumper-2
Q1: IRLM6402; Package_SOT-23
R1, R2, R3, R4: 5.1k; Register_0603_1608
R5: 56k; Register_0603_1608
SW1: SW_Locking; Switch_Locking_Button_8x8mm
U1: CH217K; Package_SOT-23-6

Connections:
/CONN_VBUS: D1.2 (A), D3.1 (K), JP1.1 (A), JP3.2 (B)
/OUT_VBUS: C1.1, C2.1, D1.1 (K), J3.1 (VBUS), JP1.2 (B), Q1.2 (S), U1.1 (VOUT)
/PWR_SW: C3.1, Q1.1 (G), SW1.1 (B), SW1.4 (E), U1.4 (EN#)
/PWR_VBUS: D2.1 (K), JP2.2 (B), Q1.3 (D), SW1.3 (A), SW1.6 (D), U1.6 (VIN)
/USBDM: J2.2 (D-), J3.2 (D-)
/USBDP: J2.3 (D+), J3.3 (D+)
GND: C1.2, C2.2, C3.2, J1.4 (GND), J1.S1 (SHIELD), J2.4 (GND), J2.S1 (SHIELD), J3.4 (GND), J3.S1 (SHIELD), R1.2, R2.2, R3.2, R4.2, R5.2, SW1.2 (C), SW1.5 (F), U1.2 (GND)
unnamed: D2.2 (A), J1.1 (VBUS), JP2.1 (A)
unnamed: D3.2 (A), J2.1 (VBUS), JP3.1 (A)
unnamed: J1.5 (CC1), R1.1
unnamed: J1.6 (CC2), R2.1
unnamed: J2.5 (CC1), R3.1
unnamed: J2.6 (CC2), R4.1
unnamed: R5.1, U1.5 (ISET)

Notes on the sheet:
CH217Kによる制御
Pch-MOSFETによる制御

Board: 2 copper layers, 36.0 x 23.0 mm, 22 parts (2 on the bottom side), 14 nets.

Other parts of the board:
MISC-ACCOUNTTEXT: Logo_74th_text
MISC-ICON: LOGO; Logo_74th_7.5mm

## KiCad design 74TH-G068-1Key_CH32V003/74TH-G068-1Key_CH32V003.kicad_pcb

File 74TH-G068-1Key_CH32V003/README.md:

# 30円マイコン CH32V003 を使った1%キーキーボード

### 製作記事

> 激安マイコンCH32V003を使って、キーストロークを入力する1%キーボードを作る - @74thの製作ログ</br>
> https://74th.hateblo.jp/entry/ch32v003-1key

Parts:
C1, C2: 10u; Capacitor_0603_1608_WithSizeText
C3: 0.1u; Capacitor_0603_1608_WithSizeText
CH1: SWD; PinOut_Pin_3_3GND
D1: SK6812MINI-E_RGBLED; LED_SK6812MINI-E_BACK-RIGHT
J1: USB2.0-C_SMT; Connector_USB-C-Receptacle_SMT_12-Pin_Simple
R1, R3: 10; Register_0603_1608_WithSizeText
R2: 1.5k; Register_0603_1608_WithSizeText
R4, R5: 5.1k; Register_0603_1608_WithSizeText
R6: 27; Register_0603_1608_WithSizeText
SW1: SW_Push; Switch_MXChoc_1.0u
U1: CH32V003F4P6; Package_TSSOP-20_4.4x6.5mm_P0.65mm
U2: AMS1117; Package_SOT-89-3
U3: CH213K; Package_SOT-23

Connections:
+3V3: C2.1, C3.1, CH1.1 (VCC), D1.1 (VDD), U1.9 (VDD), U3.2 (VO-)
+5V: C1.1, J1.1 (VBUS), U2.3 (VI)
/D+: J1.3 (D+), R1.1
/D-: J1.2 (D-), R2.1, R3.1
/SWDIO: CH1.2 (SWIO), U1.18 (SWIO/PD1)
GND: C1.2, C2.2, C3.2, CH1.3 (GND), D1.3 (GND), J1.4 (GND), J1.S1 (SHIELD), R4.1, R5.1, SW1.2, U1.7 (VSS), U2.1 (GND), U3.1 (GND)
unnamed: D1.4 (DIN), R6.2
unnamed: J1.5 (CC1), R4.2
unnamed: J1.6 (CC2), R5.2
unnamed: SW1.1, U1.10 (PC0)
unnamed: R6.1, U1.13 (PC3)
unnamed: R1.2, U1.20 (PD3/UART_CTS/ADC4)
unnamed: R3.2, U1.1 (PD4/UART_CK/ADC7)
unnamed: R2.2, U1.2 (PD5/UART_TX/ADC5)
unnamed: U2.2 (VO), U3.3 (VI+)

Board: 2 copper layers, 19.0 x 37.1 mm, 21 parts (9 on the bottom side), 15 nets.

Other parts of the board:
M2, M2#2, M2#3, M2#4: Hole_M2_2.2-TH
MISC-ICON: LOGO; Logo_74th_4mm

## KiCad design 74TH-G067-button_unit_grove_i2c/button_unit_grove_i2c.kicad_pcb

Parts:
C1: 0.1u; Capacitor_0805_2012_WithSizeText
C3, C4: 1u; Capacitor_0805_2012_WithSizeText
CH1: Grove I2C; Connector_HY-2.0_SMD_4Pin
CH2: SWD 1Wire & UART TX; PinOut_Pin_4
D1, D2, D3, D4: SK6812MINI; LED_SK6812MINI-E_BACK-RIGHT
R1: 10k; Register_0805_2012_WithSizeText
R2: 27; Register_0805_2012_WithSizeText
R3, R4: 1k; Register_0805_2012_WithSizeText
SW1, SW2, SW3, SW4: SW_Push; Switch_MXChoc_1.0u
U1: CH32V003F4P6; Package_TSSOP-20_4.4x6.5mm_P0.65mm
U2: AMS1117; Package_SOT-89-3
U3: CH213K; Package_SOT-23

Connections:
+3V3: C1.1, C3.1, R3.1, R4.1, U1.9 (VDD), U3.2 (VO-)
+5V: C4.1, CH1.3 (VCC), CH2.1 (VCC), D1.1 (VDD), D2.1 (VDD), D3.1 (VDD), D4.1 (VDD), R1.1, U2.3 (VI)
/LED: R2.2, U1.16 (PC6/SPI_MOSI)
/SCL: CH1.1 (SCL), R3.2, U1.12 (PC2/I2C_SCL/UART_RTS)
/SDA: CH1.2 (SDA), R4.2, U1.11 (PC1/I2C_SDA/SPI_NSS)
/SW1: SW1.1, U1.13 (PC3)
/SW2: SW2.1, U1.14 (PC4/ADC2)
/SW3: SW3.1, U1.15 (PC5/SPI_SCK)
/SW4: SW4.1, U1.17 (PC7/SPI_MISO)
/SWDIO: CH2.2 (SWDIO), U1.18 (SWIO/PD1)
/TXD: CH2.4 (TXD), U1.2 (PD5/UART_TX/ADC5)
GND: C1.2, C3.2, C4.2, CH1.4 (GND), CH2.3 (GND), D1.3 (GND), D2.3 (GND), D3.3 (GND), D4.3 (GND), U1.7 (VSS), U2.1 (GND), U3.1 (GND)
unnamed: D1.4 (DIN), R2.1
unnamed: D1.2 (DOUT), D2.4 (DIN)
unnamed: D2.2 (DOUT), D3.4 (DIN)
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: R1.2, SW1.2, SW2.2, SW3.2, SW4.2
unnamed: U2.2 (VO), U3.3 (VI+)

Notes on the sheet:
LED
Debug Ports
Switch
MCU
Grove Port
